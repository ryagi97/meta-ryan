FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://0001-boneblack-uses-ryan-s-dtb.patch \
"